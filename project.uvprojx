# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa156 (6230000::V6.23::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.06.00
  cpu: IRAM(0x20000000,0x01e000) IRAM2(0x04000000,0x3000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: DEBUG, __RTTHREAD__, RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, CPU_MCXA156VLL, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: packages\CMSIS-DSP-latest\Include\dsp;board\ports;rt-thread\components\utilities\resource;rt-thread\components\drivers\include;packages\pahomqtt-latest\MQTTPacket\src;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\phy;rt-thread\include;rt-thread\components\net\netdev\include;rt-thread\libcpu\arm\cortex-m33;packages\cJSON-v1.7.17;rt-thread\components\net\sal\include;rt-thread\components\drivers\smp_call;rt-thread\components\libc\posix\io\eventfd;packages\nxp-mcx-series-latest\MCXA156;packages\pahomqtt-latest\MQTTClient-RT;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\net\at\include;packages\nxp-mcx-cmsis-latest\Core\Include;rt-thread\components\utilities\ulog;packages\onenet-latest\inc;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\drivers\include;packages\at_device-latest\inc;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\libcpu\arm\common;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\port;packages\CMSIS-DSP-latest\Include;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\inc;packages\nxp-mcx-series-latest\MCXA156\components\codec;.;rt-thread\components\net\sal\impl;packages\nxp-mcx-series-latest\MCXA156\drivers;applications;rt-thread\components\net\at\at_socket;rt-thread\components\dfs\dfs_v1\include;packages\CMSIS-DSP-latest\PrivateInclude;board\MCUX_Config\board;rt-thread\components\drivers\include;rt-thread\components\net\utest;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;board;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\libc\posix\io\poll;Libraries\drivers\config;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\compilers\common\include;packages\at_device-latest\class\esp8266;Libraries\drivers;.\applications\Bsp
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: .\board\linker_scripts\MCXA156_flash.scf
  group Applications
    applications/: main.c
    ./applications/Bsp/: collect_handle.c user_thread.c
  group AT
    rt-thread/components/net/at/src/: at_client.c at_utils.c at_cli.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/src/: at_device.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON.c cJSON_Utils.c
  group CMSIS_DSP
    packages/CMSIS-DSP-latest/Source/StatisticsFunctions/: StatisticsFunctionsF16.c StatisticsFunctions.c
    packages/CMSIS-DSP-latest/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    packages/CMSIS-DSP-latest/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    packages/CMSIS-DSP-latest/Source/SupportFunctions/: SupportFunctionsF16.c SupportFunctions.c
    packages/CMSIS-DSP-latest/Source/BasicMathFunctions/: BasicMathFunctionsF16.c BasicMathFunctions.c
    packages/CMSIS-DSP-latest/Source/TransformFunctions/: TransformFunctionsF16.c TransformFunctions.c
    packages/CMSIS-DSP-latest/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    packages/CMSIS-DSP-latest/Source/ComplexMathFunctions/: ComplexMathFunctionsF16.c ComplexMathFunctions.c
    packages/CMSIS-DSP-latest/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    packages/CMSIS-DSP-latest/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    packages/CMSIS-DSP-latest/Source/MatrixFunctions/: MatrixFunctionsF16.c MatrixFunctions.c
    packages/CMSIS-DSP-latest/Source/FastMathFunctions/: FastMathFunctionsF16.c FastMathFunctions.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    board/ports/: drv_spi_sample_rw007.c
    Libraries/drivers/: drv_adc.c drv_pin.c drv_uart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh_file.c cmd.c msh.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstdio.c kerrno.c rt_vsnprintf_std.c rt_vsscanf.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXA156/arm/: startup_MCXA156.s
    packages/nxp-mcx-series-latest/MCXA156/drivers/: fsl_aoi.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_eqdc.c fsl_erm.c fsl_freqme.c fsl_glikey.c fsl_gpio.c fsl_i3c.c fsl_i3c_edma.c fsl_inputmux.c fsl_lpadc.c fsl_lpcmp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ostimer.c fsl_pwm.c fsl_reset.c fsl_spc.c fsl_utick.c fsl_vbat.c fsl_waketimer.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXA156/: system_MCXA156.c
  group onenet
    packages/onenet-latest/src/: onenet_mqtt.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTPacket.c MQTTSerializePublish.c MQTTUnsubscribeServer.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTUnsubscribeClient.c MQTTSubscribeClient.c MQTTConnectClient.c MQTTFormat.c MQTTSubscribeServer.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group Utilities
    rt-thread/components/utilities/resource/: resource_id.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
